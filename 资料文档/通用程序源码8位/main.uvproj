# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F340 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: 1221_CTC24_GC9306_8并_快B +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.h main.c USBX_F34X.LIB readme.txt
    ./mmc_sd/: mmc_sd.c
    ./lcd/: lcd.c
    ./tp/: tp.c
