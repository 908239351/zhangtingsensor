# Keil uVision project detector.uvprojx, settings and files
target Detector (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: detector
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARE;..\STM32F10x_FWLib\inc;..\SYSTEM;..\USER;..\FATFS\src;..\FATFS\exfuns;..\TEXT
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Core
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group HAREWARE
    ../HARDWARE/: wdg.c uart3.c uart2.c timer.c led.c SHT2x.c key.c lcd_task.c adc.c malloc.c sdio_sdcard.c spi.c w25qxx.c gc9306.c key_task.c
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c misc.c stm32f10x_dma.c stm32f10x_sdio.c stm32f10x_spi.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ../FATFS/src/: diskio.c ff.c
  group TEXT
    ../TEXT/: fontupd.c text.c
